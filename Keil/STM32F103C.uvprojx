# Keil uVision project STM32F103C.uvprojx, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_25MHZ,HSE_VALUE=25000000,DEBUG,TRACE
  c include: ..\include;..\include\mylib;..\include\user;..\system\include\cmsis;..\system\include\stm32f1-stdperiph;..\system\include
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\STM32F103C.sct
  group system
    ../system/src/cmsis/: stack_heap_stm32f10x.c system_stm32f10x.c vectors_stm32f10x.c
    ../system/src/cortexm/: _initialize_hardware.c _reset_hardware.c exception_handlers.c
    ../system/src/diag/: Trace.c trace_impl.c
    ../system/src/newlib/: _exit.c _sbrk.c _startup.c _syscalls.c assert.c
  group stdperiph
    ../system/src/stm32f1-stdperiph/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group mylib
    ../src/mylib/: ad.c beep.c can.c delay.c encoder.c flash.c key.c led.c pwm.c sys.c tim2.c usart2.c
  group user
    ../src/user/: debug.c main.c motor.c PID.c stm32f10x_it.c util.c
